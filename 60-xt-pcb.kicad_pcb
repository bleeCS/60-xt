# Repository bleeCS/60-xt

File README.md:

# 60-xt
 
PCB for 60% keyboard with XT function row.

## KiCad design 60-xt-pcb.kicad_pcb

Parts:
C1, C2, C12: 1uF; C_0603_1608Metric
C3, C8, C10: 4.7uF; C_0603_1608Metric
C4: 470nF; C_0603_1608Metric
C5: 0.1uF; C_0603_1608Metric
C6, C7, C9: 100nF; C_0603_1608Metric
C11: 10nF; C_0603_1608Metric
D1: D_Schottky; D_SOD-123
D2: D_TVS; D_SOD-123
D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74: D_Small; D_SOD-123
F1: 500mA; Fuse_1206_3216Metric
J1: Conn_01x04; JST-SR-4
LOGO1: O-LOGO; o-logo-300dpi
LOGO2: O-LOGO; o-logo-back-300dpi
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX15, MX17, MX18, MX19, MX20, MX22, MX23, MX24, MX25, MX26, MX27, MX28, MX29, MX30, MX31, MX32, MX33, MX35, MX36, MX39, MX40, MX41, MX42, MX43, MX44, MX45, MX46, MX47, MX48, MX49, MX51, MX52, MX54, MX55, MX56, MX57, MX58, MX59, MX60, MX61, MX62, MX63, MX66, MX67, MX68, MX70, MX74: MX-NoLED; MXOnly-1U-NoLED
MX16: MX-NoLED; MXOnly-2U-NoLED
MX21, MX34, MX69, MX71, MX73, MX75: MX-NoLED; MXOnly-1.5U-NoLED
MX37: MX-LED; MXOnly-1.25U-FLIPPED
MX38: MX-LED; MXOnly-1.75U
MX50: MX-NoLED; MXOnly-2.25U-ReversedStabilizers-NoLED
MX53: MX-NoLED; MXOnly-2.25U-NoLED
MX64: MX-NoLED; MXOnly-2.75U-NoLED
MX65: MX-NoLED; MXOnly-1.75U-NoLED
MX72: MX-NoLED; MXOnly-7U-ReversedStabilizers-NoLED
Q1: 2N7002; SOT-23
R1, R2: 10k; R_0603_1608Metric
R3: 100k; R_0603_1608Metric
R4: 1k; R_0603_1608Metric
SW1: SW_Push; K2-1187SQ-A4SW-06
U1: MCP1700-3302E_SOT23; SOT-23
U2: STM32F072CBTx; LQFP-48_7x7mm_P0.5mm

Connections:
+3V3: C2.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, D1.2 (A), R1.1, SW1.2, U1.2 (VO), U2.1 (VBAT), U2.9 (VDDA), U2.24 (VDD), U2.36 (VDDIO2), U2.48 (VDD)
+5V: C1.1, D1.1 (K), D2.2 (A2), F1.1, MX37.3 (LED), MX38.3 (LED), U1.3 (VI)
BOOT0: C3.2, R2.1, SW1.1, U2.44 (BOOT0)
CAPS: R4.1, U2.31 (PA10)
Col0: MX1.1 (COL), MX19.1 (COL), MX35.1 (COL), MX51.1 (COL), MX67.1 (COL), U2.42 (PB6)
Col1: MX2.1 (COL), MX20.1 (COL), MX36.1 (COL), MX52.1 (COL), MX68.1 (COL), U2.41 (PB5)
Col2: MX3.1 (COL), MX21.1 (COL), MX37.2 (ROW), MX38.1 (COL), MX53.1 (COL), MX69.1 (COL), U2.39 (PB3)
Col3: MX4.1 (COL), MX22.1 (COL), MX39.1 (COL), MX54.1 (COL), MX70.1 (COL), U2.13 (PA3)
Col4: MX5.1 (COL), MX23.1 (COL), MX40.1 (COL), MX55.1 (COL), MX71.1 (COL), U2.27 (PB14)
Col5: MX6.1 (COL), MX24.1 (COL), MX41.1 (COL), MX56.1 (COL), U2.26 (PB13)
Col6: MX7.1 (COL), MX25.1 (COL), MX42.1 (COL), MX57.1 (COL), U2.25 (PB12)
Col7: MX8.1 (COL), MX26.1 (COL), MX43.1 (COL), MX58.1 (COL), U2.22 (PB11)
Col8: MX9.1 (COL), MX27.1 (COL), MX44.1 (COL), MX59.1 (COL), MX72.1 (COL), U2.21 (PB10)
Col9: MX10.1 (COL), MX28.1 (COL), MX45.1 (COL), MX60.1 (COL), U2.20 (PB2)
Col10: MX11.1 (COL), MX29.1 (COL), MX46.1 (COL), MX61.1 (COL), U2.19 (PB1)
Col11: MX12.1 (COL), MX30.1 (COL), MX47.1 (COL), MX62.1 (COL), U2.18 (PB0)
Col12: MX13.1 (COL), MX31.1 (COL), MX48.1 (COL), MX63.1 (COL), MX73.1 (COL), U2.17 (PA7)
Col13: MX14.1 (COL), MX32.1 (COL), MX49.1 (COL), MX74.1 (COL), U2.16 (PA6)
Col14: MX15.1 (COL), MX33.1 (COL), MX50.1 (COL), MX64.1 (COL), MX65.1 (COL), U2.15 (PA5)
Col15: MX16.1 (COL), MX17.1 (COL), MX18.1 (COL), MX34.1 (COL), MX66.1 (COL), MX75.1 (COL), U2.14 (PA4)
D+: J1.3, U2.33 (PA12)
D-: J1.2, U2.32 (PA11)
GND: C1.2, C2.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D2.1 (A1), J1.4, Q1.2 (S), R2.2, R3.2, U1.1 (GND), U2.8 (VSSA), U2.23 (VSS), U2.35 (VSS), U2.47 (VSS)
NRST: C4.2, Q1.3 (D), R1.2, U2.7 (NRST)
unnamed: C3.1, Q1.1 (G), R3.1
unnamed: D3.2 (A), MX1.2 (ROW)
unnamed: D4.2 (A), MX2.2 (ROW)
unnamed: D5.2 (A), MX3.2 (ROW)
unnamed: D6.2 (A), MX4.2 (ROW)
unnamed: D7.2 (A), MX5.2 (ROW)
unnamed: D8.2 (A), MX6.2 (ROW)
unnamed: D9.2 (A), MX7.2 (ROW)
unnamed: D10.2 (A), MX8.2 (ROW)
unnamed: D11.2 (A), MX9.2 (ROW)
unnamed: D12.2 (A), MX10.2 (ROW)
unnamed: D13.2 (A), MX11.2 (ROW)
unnamed: D14.2 (A), MX12.2 (ROW)
unnamed: D15.2 (A), MX13.2 (ROW)
unnamed: D16.2 (A), MX14.2 (ROW)
unnamed: D17.2 (A), MX15.2 (ROW)
unnamed: D18.2 (A), MX16.2 (ROW), MX17.2 (ROW)
unnamed: D19.2 (A), MX18.2 (ROW)
unnamed: D20.2 (A), MX19.2 (ROW)
unnamed: D21.2 (A), MX20.2 (ROW)
unnamed: D22.2 (A), MX21.2 (ROW)
unnamed: D23.2 (A), MX22.2 (ROW)
unnamed: D24.2 (A), MX23.2 (ROW)
unnamed: D25.2 (A), MX24.2 (ROW)
unnamed: D26.2 (A), MX25.2 (ROW)
unnamed: D27.2 (A), MX26.2 (ROW)
unnamed: D28.2 (A), MX27.2 (ROW)
unnamed: D29.2 (A), MX28.2 (ROW)
unnamed: D30.2 (A), MX29.2 (ROW)
unnamed: D31.2 (A), MX30.2 (ROW)
unnamed: D32.2 (A), MX31.2 (ROW)
unnamed: D33.2 (A), MX32.2 (ROW)
unnamed: D34.2 (A), MX33.2 (ROW)
unnamed: D35.2 (A), MX34.2 (ROW)
unnamed: D36.2 (A), MX35.2 (ROW)
unnamed: D37.2 (A), MX36.2 (ROW)
unnamed: D38.2 (A), MX37.1 (COL), MX38.2 (ROW)
unnamed: D39.2 (A), MX39.2 (ROW)
unnamed: D40.2 (A), MX40.2 (ROW)
unnamed: D41.2 (A), MX41.2 (ROW)
unnamed: D42.2 (A), MX42.2 (ROW)
unnamed: D43.2 (A), MX43.2 (ROW)
unnamed: D44.2 (A), MX44.2 (ROW)
unnamed: D45.2 (A), MX45.2 (ROW)
unnamed: D46.2 (A), MX46.2 (ROW)
unnamed: D47.2 (A), MX47.2 (ROW)
unnamed: D48.2 (A), MX48.2 (ROW)
unnamed: D49.2 (A), MX49.2 (ROW)
unnamed: D50.2 (A), MX50.2 (ROW)
unnamed: D51.2 (A), MX51.2 (ROW)
unnamed: D52.2 (A), MX52.2 (ROW)
unnamed: D53.2 (A), MX53.2 (ROW)
unnamed: D54.2 (A), MX54.2 (ROW)
unnamed: D55.2 (A), MX55.2 (ROW)
unnamed: D56.2 (A), MX56.2 (ROW)
unnamed: D57.2 (A), MX57.2 (ROW)
unnamed: D58.2 (A), MX58.2 (ROW)
unnamed: D59.2 (A), MX59.2 (ROW)
unnamed: D60.2 (A), MX60.2 (ROW)
unnamed: D61.2 (A), MX61.2 (ROW)
unnamed: D62.2 (A), MX62.2 (ROW)
unnamed: D63.2 (A), MX63.2 (ROW)
unnamed: D64.2 (A), MX64.2 (ROW), MX65.2 (ROW)
unnamed: D65.2 (A), MX66.2 (ROW)
unnamed: D66.2 (A), MX67.2 (ROW)
unnamed: D67.2 (A), MX68.2 (ROW)
unnamed: D68.2 (A), MX69.2 (ROW)
unnamed: D69.2 (A), MX70.2 (ROW)
unnamed: D70.2 (A), MX71.2 (ROW)
unnamed: D71.2 (A), MX72.2 (ROW)
unnamed: D72.2 (A), MX73.2 (ROW)
unnamed: D73.2 (A), MX74.2 (ROW)
unnamed: D74.2 (A), MX75.2 (ROW)
unnamed: MX37.4 (LEDGND), MX38.4 (LEDGND), R4.2
Row0: D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U2.46 (PB9)
Row1: D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), U2.5 (PF0)
Row2: D19.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), U2.40 (PB4)
Row3: D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), U2.43 (PB7)
Row4: D66.1 (K), D67.1 (K), D68.1 (K), D69.1 (K), D70.1 (K), D71.1 (K), D72.1 (K), D73.1 (K), D74.1 (K), U2.45 (PB8)
VCC: F1.2, J1.1

Board: 2 copper layers, 327.1 x 93.8 mm, 173 parts (95 on the bottom side), 104 nets.

## Commit log

2021-01-10 initialize kicad project
2021-01-10 add project submodules
2021-01-11 finish schem, place switches and diodes on pcb, update readme, other small changes
2021-01-16 finish routing, add logos
